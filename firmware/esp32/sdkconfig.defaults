## firmware/esp32/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_CSI_ENABLED=y
CONFIG_ESP_WIFI_SLP_DEFAULT_MIN_ACTIVE_TIME=0
CONFIG_ESP_WIFI_SLP_DEFAULT_MAX_ACTIVE_TIME=0
```
